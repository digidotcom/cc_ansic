# IAR project etherios_app.ewp, settings and files
configuration twrk60n512_Int_Flash_Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWRK60N512
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\shell; C:\Etherios4Kinetis\Etherios_CC\include; C:\Etherios4Kinetis\Etherios_CC\platform\mqx; C:\Etherios4Kinetis\Etherios_CC\private; C:\CyaSSL-2.6.0_libs; Sources; Sources\fs_devices
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\shell
  OBJCOPY.OOCOutputFile: device_request_mqx_4.0.srec
  ILINK.IlinkOutputFile: ic4mqx_1.3.out
  ILINK.IlinkIcfFile: C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\psp\psp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\bsp\bsp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\rtcs\rtcs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\mfs\mfs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\debug\usb\usbh.a; C:\CyaSSL-2.6.0_libs\IAR\twrk60n512\cyassl.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration twrk60n512_Int_Flash_Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\shell; C:\Etherios4Kinetis\Etherios_CC\include; C:\Etherios4Kinetis\Etherios_CC\platform\mqx; C:\Etherios4Kinetis\Etherios_CC\private; C:\CyaSSL-2.6.0_libs; Sources; Sources\fs_devices
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\shell; ..
  OBJCOPY.OOCOutputFile: etherios_app.srec
  ILINK.IlinkIcfFile: C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\psp\psp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\bsp\bsp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\rtcs\rtcs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\mfs\mfs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk60n512.iar\release\usb\usbh.a; C:\CyaSSL-2.6.0_libs\IAR\twrk60n512\cyassl.a
configuration twrk53n512_Int_Flash_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  ICCARM.CCDefines: IAR; TWRK53N512
  ICCARM.CCIncludePath2: C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\shell; C:\Etherios4Kinetis\Etherios_CC\include; C:\Etherios4Kinetis\Etherios_CC\platform\mqx; C:\Etherios4Kinetis\Etherios_CC\private; C:\CyaSSL-2.6.0_libs; Sources; Sources\fs_devices
  AARM.AUserIncludes: C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\shell
  ILINK.IlinkIcfFile: C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\psp\psp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\bsp\bsp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\rtcs\rtcs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\mfs\mfs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\debug\usb\usbh.a; C:\CyaSSL-2.6.0_libs\IAR\twrk53n512\cyassl.a
configuration twrk53n512_Int_Flash_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  ICCARM.CCDefines: IAR; TWRK53N512
  ICCARM.CCIncludePath2: C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\shell; C:\Etherios4Kinetis\Etherios_CC\include; C:\Etherios4Kinetis\Etherios_CC\platform\mqx; C:\Etherios4Kinetis\Etherios_CC\private; C:\CyaSSL-2.6.0_libs; Sources; Sources\fs_devices
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: etherios_app.srec
  ILINK.IlinkIcfFile: C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\bsp\intflash.icf
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\psp\psp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\bsp\bsp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\rtcs\rtcs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\mfs\mfs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk53n512.iar\release\usb\usbh.a; C:\CyaSSL-2.6.0_libs\IAR\twrk53n512\cyassl.a
configuration twrk70f120m_Int_Flash_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  ICCARM.CCDefines: IAR; TWRK70F120M
  ICCARM.CCIncludePath2: C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\shell; C:\Etherios4Kinetis\Etherios_CC\include; C:\Etherios4Kinetis\Etherios_CC\platform\mqx; C:\Etherios4Kinetis\Etherios_CC\private; C:\CyaSSL-2.6.0_libs; Sources; Sources\fs_devices
  AARM.AUserIncludes: C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\shell
  ILINK.IlinkIcfFile: C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\bsp\intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\psp\psp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\bsp\bsp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\rtcs\rtcs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\mfs\mfs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\usb\usbh.a; C:\CyaSSL-2.6.0_libs\IAR\twrk70f120m\cyassl.a
configuration twrk70f120m_Int_Flash_Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  ICCARM.CCDefines: IAR; TWRK70F120M
  ICCARM.CCIncludePath2: C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\shell; C:\Etherios4Kinetis\Etherios_CC\include; C:\Etherios4Kinetis\Etherios_CC\platform\mqx; C:\Etherios4Kinetis\Etherios_CC\private; C:\CyaSSL-2.6.0_libs; Sources; Sources\fs_devices
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\bsp; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\psp; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\bsp\Generated_Code; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\rtcs; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\mfs; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\usb; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\shell; ..
  OBJCOPY.OOCOutputFile: etherios_app.srec
  ILINK.IlinkIcfFile: C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\bsp\intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\debug\psp\psp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\bsp\bsp.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\rtcs\rtcs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\mfs\mfs.a; C:\Freescale\Freescale_MQX_4_0\lib\twrk70f120m.iar\release\usb\usbh.a; C:\CyaSSL-2.6.0_libs\IAR\twrk70f120m\cyassl.a
configuration twrk60n512_FirmwareUpdate (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: etherios_app.srec
  ILINK.IlinkIcfFile: C:\Etherios4Kinetis\Tools\FWUpdateIntFlash.icf
  ILINK.IlinkAdditionalLibs: as above
  group (top)
    ./: ReadMe.txt
  group Source
    Sources/: application.c connector_config.h connector_hooks.c main.c main.h
  group Source/Etherios Connector/include
    ../../../../Etherios_CC/include/: connector.h connector_api.h connector_api_config.h connector_api_data_point.h connector_api_data_service.h connector_api_file_system.h connector_api_firmware.h connector_api_network.h connector_api_os.h connector_api_remote.h connector_api_short_message.h connector_debug.h connector_types.h data_point.h data_service.h os_support.h
  group Source/Etherios Connector/platform/mqx
    ../../../../Etherios_CC/platform/mqx/: config.c config.rci connector.c data_point.c data_service.c debug.c etherios-ca-cert-public.crt.c file_system.c firmware_mqx.c firmware_mqx.h firmware_mqx_iar.h firmware_stub.c firmware_twrk60.c flash_mqx.c flash_mqx.h flash_mqx_iar.h network.c network_ssl.c os.c os_support.c platform.h
  group Source/Etherios Connector/private
    ../../../../Etherios_CC/private/: bele.h chk_config.h connector_api.c connector_cc.h connector_data_point.h connector_data_service.h connector_def.h connector_edp.h connector_edp_def.h connector_edp_util.h connector_file_system.h connector_firmware.h connector_global_config.h connector_info.h connector_msg.h connector_sm.h connector_sm_cmd.h connector_sm_def.h connector_sm_recv.h connector_sm_send.h connector_sm_session.h connector_sm_utils.h connector_static_buffer.h connector_tcp_close.h connector_tcp_config.h connector_tcp_open.h connector_tcp_recv.h connector_tcp_send.h debug.h ei_packet.h layer.h os_intf.h rci_binary.h rci_binary_buffer.h rci_binary_callback.h rci_binary_debug.h rci_binary_element.h rci_binary_error.h rci_binary_group.h rci_binary_input.h rci_binary_output.h rci_binary_string.h rci_binary_support.h rci_binary_traverse.h rci_binary_util.h rci_fwstub.h rci_service.h Readme.txt
  group Source/fs_devices
    Sources/fs_devices/: MFS_USB.h sdcard_task.c sdcard_task.h usb_classes.c usb_classes.h USB_File.c USB_File.h USB_Task.c USB_Task.h
