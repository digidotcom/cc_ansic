# IAR project etherios_app.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: __RELACE_WITH__CHIP__
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\BSP; ..\..\BSP\uCOS-III; ..\..\BSP\Freescale; ..\..\BSP\uCTCPIP-V2; ..\..\..\..\..\..\uC-LIB; ..\..\..\..\..\..\uC-CPU; ..\..\..\..\..\..\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\..\uCOS-III; ..\..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\..\uCOS-III\Source; ..\..\..\..\..\..\uC-TCPIP-V2; ..\..\..\..\..\..\uC-TCPIP-V2\Source; ..\..\..\..\..\..\uC-TCPIP-V2\IF; ..\..\..\..\..\..\uC-TCPIP-V2\OS\uCOS-III; ..\..\..\..\..\..\uC-TCPIP-V2\Dev\Ether\MACNet; ..\..\..\..\..\..\uC-TCPIP-V2\Dev\Ether\PHY\Generic; ..\..\..\..\..\..\uC-DHCPc\Source; ..\..\..\..\..\..\uC-DNSc\Source; ..\..\..\..\..\..\uc-fs; ..\..\..\..\..\..\uc-fs\Source; ..\..\..\..\..\..\uc-fs\FAT; ..\..\..\..\..\..\uc-fs\OS\UCOS-III; ..\..\..\..\..\..\uc-fs\Dev\RAMDisk; ..\..\..\..\..\..\uC-Clk\Source; c:\Etherios4Kinetis\Etherios_CC\include; c:\Etherios4Kinetis\Etherios_CC\platform\ucos
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: etherios_app.srec
  ILINK.IlinkOutputFile: etherios_app.out
  ILINK.IlinkIcfFile: ..\..\BSP\Freescale\KxxX_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\BSP; ..\..\BSP\uCOS-III; ..\..\BSP\Freescale; ..\..\BSP\uCTCPIP-V2; ..\..\..\..\..\..\uC-LIB; ..\..\..\..\..\..\uC-CPU; ..\..\..\..\..\..\uC-CPU\ARM-Cortex-M4\IAR; ..\..\..\..\..\..\uCOS-III; ..\..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\..\..\..\..\uCOS-III\Source; ..\..\..\..\..\..\uC-TCPIP-V2; ..\..\..\..\..\..\uC-TCPIP-V2\Source; ..\..\..\..\..\..\uC-TCPIP-V2\IF; ..\..\..\..\..\..\uC-TCPIP-V2\OS\uCOS-III; ..\..\..\..\..\..\uC-TCPIP-V2\Dev\Ether\MACNet; ..\..\..\..\..\..\uC-TCPIP-V2\Dev\Ether\PHY\Generic; ..\..\..\..\..\..\uC-DHCPc\Source; ..\..\..\..\..\..\uC-DNSc\Source; c:\Etherios4Kinetis\Etherios_CC\include; c:\Etherios4Kinetis\Etherios_CC\platform\ucos
  ICCARM.CCOptLevel: 3
  group (top)
    ./: clk_cfg.h ReadMe.txt
  group APP
    ./: app.c app_cfg.h app_vect.c application.c connector_config.h cpu_cfg.h dhcp-c_cfg.h dns-c_cfg.h fs_app.c fs_app.h fs_app_cfg.h fs_cfg.h includes.h lib_cfg.h net_cfg.h net_dev_cfg.c net_dev_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group BSP/Freescale
    ../../BSP/Freescale/: low_level_init.c MKxxN512yyy100.h
  group BSP/Headers
    ../../BSP/: bsp.h bsp_ser.h
    ../../BSP/uCOS-III/: bsp_os.h
  group BSP/Source
    ../../BSP/: bsp.c bsp_int.c bsp_ser.c
  group BSP/uC/OS-III
    ../../BSP/uCOS-III/: bsp_os.c
  group BSP/uC/TCPIP-V2
    ../../BSP/uCTCPIP-V2/: net_bsp.c net_bsp.h
  group uC/Clk/OS/uCOS-III
    ../../../../../../uC-Clk/OS/uCOS-III/: clk_os.c
  group uC/Clk/Source
    ../../../../../../uC-Clk/Source/: clk.c clk.h
  group uC/CPU/Headers
    ../../../../../../uC-CPU/ARM-Cortex-M4/IAR/: cpu.h
    ../../../../../../uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/Source
    ../../../../../../uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../../../../../../uC-CPU/: cpu_core.c
  group uC/DHCPc/Header
    ../../../../../../uC-DHCPc/Source/: dhcp-c.h
  group uC/DHCPc/Source
    ../../../../../../uC-DHCPc/Source/: dhcp-c.c
  group uC/DHCPc/uC/OS-III
    ../../../../../../uC-DHCPc/OS/uCOS-III/: dhcp-c_os.c
  group uC/DNSc/Source
    ../../../../../../uC-DNSc/Source/: dns-c.c
  group uC/EtheriosCloudConnector/Headers
    ../../../../../../../../../Etherios_CC/include/: connector.h connector_api.h connector_api_config.h connector_api_data_point.h connector_api_data_service.h connector_api_file_system.h connector_api_firmware.h connector_api_network.h connector_api_os.h connector_api_remote.h connector_api_short_message.h connector_debug.h connector_types.h data_service.h os_support.h
  group uC/EtheriosCloudConnector/Library/platform
    ../../../../../../../../../Etherios_CC/platform/ucos/: config.c connector.c data_service.c debug.c file_system.c firmware_stub.c network.c platform.h
  group uC/EtheriosCloudConnector/Library/private
    ../../../../../../../../../Etherios_CC/private/: bele.h chk_config.h connector_api.c connector_cc.h connector_data_point.h connector_data_service.h connector_def.h connector_edp.h connector_edp_def.h connector_edp_util.h connector_file_system.h connector_firmware.h connector_global_config.h connector_info.h connector_msg.h connector_sm.h connector_sm_cmd.h connector_sm_def.h connector_sm_recv.h connector_sm_send.h connector_sm_session.h connector_sm_utils.h connector_static_buffer.h connector_tcp_close.h connector_tcp_config.h connector_tcp_open.h connector_tcp_recv.h connector_tcp_send.h debug.h ei_packet.h layer.h os_intf.h rci_binary.h rci_binary_buffer.h rci_binary_callback.h rci_binary_debug.h rci_binary_element.h rci_binary_error.h rci_binary_group.h rci_binary_input.h rci_binary_output.h rci_binary_string.h rci_binary_support.h rci_binary_traverse.h rci_binary_util.h rci_fwstub.h rci_service.h
  group uC/EtheriosCloudConnector/OS/ucos-iii
    ../../../../../../../../../Etherios_CC/platform/ucos/ucos-iii/: os.c os_support.c
  group uC/FS/Dev/RamDisk
    ../../../../../../uC-FS/Dev/RAMDisk/: fs_dev_ramdisk.c fs_dev_ramdisk.h
  group uC/FS/FAT
    ../../../../../../uC-FS/FAT/: fs_fat.c fs_fat.h fs_fat_dir.c fs_fat_dir.h fs_fat_entry.c fs_fat_entry.h fs_fat_fat12.c fs_fat_fat12.h fs_fat_fat16.c fs_fat_fat16.h fs_fat_fat32.c fs_fat_fat32.h fs_fat_file.c fs_fat_file.h fs_fat_journal.c fs_fat_journal.h fs_fat_lfn.c fs_fat_lfn.h fs_fat_sfn.c fs_fat_sfn.h fs_fat_type.h
  group uC/FS/OS/uCOS-III
    ../../../../../../uC-FS/OS/uCOS-III/: fs_os.c fs_os.h
  group uC/FS/Source
    ../../../../../../uC-FS/Source/: fs.c fs.h fs_api.c fs_api.h fs_buf.c fs_buf.h fs_cache.c fs_cache.h fs_cfg_fs.h fs_ctr.h fs_def.h fs_dev.c fs_dev.h fs_dir.c fs_dir.h fs_entry.c fs_entry.h fs_err.h fs_file.c fs_file.h fs_inc.h fs_partition.c fs_partition.h fs_sys.c fs_sys.h fs_type.h fs_unicode.c fs_unicode.h fs_util.c fs_util.h fs_vol.c fs_vol.h
  group uC/LIB/Headers
    ../../../../../../uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Source
    ../../../../../../uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III/Headers
    ../../../../../../uCOS-III/Source/: os.h
    ../../../../../../uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu.h
  group uC/OS-III/Source
    ../../../../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group uC/OS-III/Source/Port
    ../../../../../../uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group uC/TCPIP-V2
    ../../../../../../uC-TCPIP-V2/Ports/IAR/: __dbg_net.c
  group uC/TCPIP-V2/DEV
    ../../../../../../uC-TCPIP-V2/Dev/Ether/MACNet/: net_dev_macnet.c
    ../../../../../../uC-TCPIP-V2/Dev/Ether/PHY/Generic/: net_phy.c
  group uC/TCPIP-V2/Headers
    ../../../../../../uC-TCPIP-V2/Source/: net.h net_app.h net_arp.h net_ascii.h net_bsd.h net_buf.h net_cfg_net.h net_conn.h net_ctr.h net_dbg.h net_def.h net_err.h net_icmp.h net_igmp.h net_ip.h net_mgr.h net_sock.h net_stat.h net_tcp.h net_tmr.h net_type.h net_udp.h net_util.h
  group uC/TCPIP-V2/IF
    ../../../../../../uC-TCPIP-V2/IF/: net_if.c net_if_802x.c net_if_ether.c net_if_loopback.c
  group uC/TCPIP-V2/Source
    ../../../../../../uC-TCPIP-V2/Source/: net.c net_app.c net_arp.c net_ascii.c net_bsd.c net_buf.c net_conn.c net_ctr.c net_dbg.c net_err.c net_icmp.c net_igmp.c net_ip.c net_mgr.c net_sock.c net_stat.c net_tcp.c net_tmr.c net_udp.c net_util.c
  group uC/TCPIP-V2/uC/OS-III
    ../../../../../../uC-TCPIP-V2/OS/uCOS-III/: net_os.c
